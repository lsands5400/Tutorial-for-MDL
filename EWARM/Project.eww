<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MDL Clinic 25-26.ewp</path>
  </project>
  <batchBuild />
</workspace>
